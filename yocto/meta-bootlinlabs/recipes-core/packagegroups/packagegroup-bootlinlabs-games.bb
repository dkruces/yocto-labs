inherit packagegroup

RDEPENDS_${PN} = "\
    ninvaders \
"
