include ninvaders.inc

SRC_URI[md5sum] = "97b2c3fb082241ab5c56ab728522622b"
SRC_URI[sha256sum] = \
  "bfbc5c378704d9cf5e7fed288dac88859149bee5ed0850175759d310b61fd30b"

SRC_URI += "file://joystick-support.patch"
